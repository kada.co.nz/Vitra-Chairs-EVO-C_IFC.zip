Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-26T17:24:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 26 17:24:14 2021 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{7A6F5941-E906-4A9A-9BC1-189226F352A1}\ifc * Database version: 5507 * Database creation date: Tue Oct 26 17:24:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 26 17:24:14 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 26 17:24:14 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: EVO-C, Vitra-Chairs-EVO-C:EVO-C:296971
In: Level 1
Type - Material: Light mint
Type - General - Author: BIMStone; BIMObjectName: Vitra-Chairs-EVO-C; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: EVO-C is a successful, uncompromising iteration of the principle and characteristics of the classic cantilever chair in the material of plastic.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 21/10/2021
Type - Identity Data - Cost: 0; Description: EVO-C is a successful, uncompromising iteration of the principle and characteristics of the classic cantilever chair in the material of plastic.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: EVO-C; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: EVO-C; URL: https://www.vitra.com/en-us/product/evo-c
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Vitra-Chairs-EVO-C; Features: n/a; Finish: n/a; Grade: n/a; Material: Polypropylene; ModelNumber: 44047800; ModelReference: n/a; Name: EVO-C; ReplacementCost: n/a; Shape: Sculptured; Size: 815x465x510 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.02914 m2; Volume: 0.192464 m3
Materials and Finishes - SeatMaterial: Light mint
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Chairs-EVO-C: EVO-C; Family and Type: Vitra-Chairs-EVO-C: EVO-C; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Chairs-EVO-C: EVO-C; Type Id: Vitra-Chairs-EVO-C: EVO-C; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
